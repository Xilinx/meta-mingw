DEPENDS_remove_mingw32 = "ncurses"
