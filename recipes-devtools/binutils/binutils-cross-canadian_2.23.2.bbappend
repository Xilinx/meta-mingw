EXTRA_OECONF_append_sdkmingw32 = " --disable-plugins --disable-nls"
LDFLAGS_append_sdkmingw32 = " -Wl,-static"
