DEPENDS_append_mingw32 = " nativesdk-mingw-w64-headers"
