FILES_${PN}-dev_append_mingw32 = " ${libdir}/*.def"
