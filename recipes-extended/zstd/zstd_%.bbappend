EXTRA_OEMAKE_append_mingw32 = " OS=Windows"
FILES_${PN}_append_mingw32 = " ${libdir}/*.dll"
