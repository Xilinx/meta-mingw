
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " \
		file://configure.ac-Set-mym4_revision-to-0-if-not-a-git-rep.patch \
		"

