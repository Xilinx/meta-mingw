PACKAGECONFIG:remove:class-nativesdk:mingw32 = "ssl"
RRECOMMENDS:lib${BPN}:remove:mingw32 = "ca-certificates"
