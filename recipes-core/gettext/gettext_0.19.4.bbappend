DEPENDS_append_mingw32 = " pthreads-win32"
LDFLAGS_prepend_mingw32 = " -lpthread "
