EXTRA_OECONF_class-nativesdk_mingw32 = "--disable-documentation --disable-libraries"

